# Keil uVision project Mini-Demo.uvprojx, settings and files
target Mini-Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mini-Demo.elf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Core\Inc;..\Libraries\CMSIS;..\User\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications/User/
    ../Applications/: main.c app-input.c app-ui.c app-signal.c
  group Drivers/User/Devices
    ../Devices/: drv-oled.c
  group Drivers/User/Protocols
    ../Protocols/: drv-iic.c drv-usart.c
  group Drivers/User/Peripherals
    ../Peripherals/: gpio.c systick.c tim.c dma.c adc.c dac.c
  group Middleware/User/Services/
    ../Services/: time-service.c graph-service.c
  group Hardware-Abs/STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_tim.c
  group Hardware-Abs/CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Hardware-Abs/MDK-ARM
    ./: startup_stm32f10x_hd.s
